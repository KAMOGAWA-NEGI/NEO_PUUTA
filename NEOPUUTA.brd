# Repository KAMOGAWA-NEGI/NEO_PUUTA

File README.md:

# NEO_PUUTA
大杉ぴゅう太さんから預かった故障個体の修理がつまずき（主にロジック周りの点検が面倒くさくてやりたくない）、いっそのこと基板自体まるごと新造しようとなりました。
作業に使ったECADソフトはAUTODESK EAGLEになります。

オリジナルとの相違点

1、PSG専用の発振器を追加

2、TMS9928換装を前提としたVDP周りの設計

3、VIDEO RAMを4464に変更

4、5V単一電源化による支障、主に12Vを要するRFモジュラー及びRGB変換基板を考慮し、DC-DCコンバーターMAU104を追加

注意事項

1、営利目的での利用は禁止ね

2、僕が基板に描いたロゴ、基板の外形、各コネクタの位置は弄らないでくださいね。他はご自由にどうぞ

3、改変、変更したら僕にDMくださいね

4、プリント基板の発注の仕方はよくわかんないけど、でも欲しいって方は僕のツイッターにDM送ってね。時期によっては手元にあまりがある時はあるから、常識的な値段でお裾分けするよ

5、PUUTAって綴りはオリジナルの基板にある表記を踏襲しているだけ、間違ってはないからその辺の指摘は受け付けないよ

現時点ラフ版

## EAGLE design NEOPUUTA.brd

Parts:
4464/1, 4464/2: DIL18
+5V, +12V: 3,81/1,4
-5V: 3,81/1,4
A4: 74AC74N; DIL14
A5: 74AC138N; DIL16
AUDIO: 973; 973_1
B3: 74AC00N; DIL14
B4: 74ACT32N; DIL14
B5, B6: 74AC138N; DIL16
B7: 74LS107N; DIL14
B-Y: 1,6/0,9
C1: 47uF; E1,8-4
C3: 74AC138N; DIL16
C4: 74AC251N; DIL16
C5: 100uF; E2,5-7
C6: 74ALS00N; DIL14
C7: 74AC00N; DIL14
C8, C9, C18: 10uF; E1,8-4
C10, C11, C12, C13, C15, C16: 103; C050-025X075
C14: 331; C050-025X075
C17: 471; C050-025X075
C53: 104; C050-025X075
C-1: 50PI_CARDEDGE_2.54MM_MOTHER; 50PIN_CARDEDGE_2.54MM
C-2: KCDX-5S-N; KCDX5SN
D1, D2, D3, D4, D5, D6, D7, D8: 1N4148DO35-10; DO35-10
GND: 3,81/1,4
H1, H2, H3, H4, H5, H6: MOUNT-PAD-SQUARE3.2; 3,2-PAD-SQUARE
IC3: 74HC244N; DIL20
IC4: 74HC04N; DIL14
J-1: EBC18DRXH
J-2: PINHD-1X16; 1X16
J-3: M09HPS; M09HP
JP1, JP2, JP3, JP4: PINHD-1X3; 1X03
OSC1: 10.738MHz; HC49/S
OSC2: PINHD-1X3; 1X03
PC1, PC2, PC3, PC4, PC5, PC6, PC7, PC8, PC9, PC10, PC11, PC12, PC13: C-EU050-025X075; C050-025X075
PC18: 471; C050-025X075
POWER: 22-23-2041
R1, R4, R5, R6, R19, R21, R22: 103; 0207/10
R2, R17: 561; 0207/10
R3, R8, R16, R20: 562; 0207/10
R7, R14, R15: 102; 0207/10
R9, R100, R101, R102: R-EU_0207/10; 0207/10
R10: 222; 0207/10
R11, R12, R13: 822; 0207/10
R18: 332; 0207/10
R23: 10; 0207/10
R-Y: 1,6/0,9
RA1: 104; RN-9
RFAUDIO: 3,81/1,4
RFGND: 3,81/1,4
RFVCC: 3,81/1,4
RFVIDEO: 3,81/1,4
SN76489A: DIL16
SYSTEM: DIL28; DIL28-6
TMS99X8, TMS9995: DIL40
TR2: -NPN-TO92-ECB; TO92-ECB
U1: MAU104
VC5V, VC12V: 1,6/0,9
VIDEO: 973; 973_1
Y: 1,6/0,9

Connections:
4W: IC4.8 (O), IC4.11 (I), JP4.1
6W: IC4.12 (O), JP4.3
+5V: 4464/1.9, 4464/2.9, +5V.1, A4.1 (CLR), A4.4 (PRE), A4.14 (VCC), A5.16 (VCC), B3.14 (VCC), B4.14 (VCC), B5.6 (G1), B5.16 (VCC), B6.16 (VCC), B7.14 (VCC), C3.16 (VCC), C4.16 (VCC), C5.+, C6.14 (VCC), C7.14 (VCC), C8.+, C9.+, C-1.P$49 (49), C-1.P$50 (50), IC3.20 (VCC), IC4.14 (VCC), J-1.A10, OSC2.3, PC1.1, PC2.1, PC3.1, PC4.1, PC5.1, PC6.1, PC7.1, PC8.1, PC9.1, PC10.1, PC11.1, PC12.1, PC13.1, PC18.1, POWER.1, R1.2, R4.2, R5.2, R6.2, R7.2, R8.2, R10.1, R19.2, R20.1, R22.2, RA1.1, SN76489A.16, SYSTEM.28, TMS99X8.33, TMS9995.10, U1.1 (+VIN), VC5V.1
+12V: +12V.1, RFVCC.1, U1.6 (+VOUT), VC12V.1
-5V: -5V.1
/CSCROM0: B5.13 (Y2), J-1.A18
/CSCROM1: A5.13 (Y2), J-1.A11
/CSPSG: A5.14 (Y1), SN76489A.6
/CSSROM: C7.6 (O), SYSTEM.20
/CSVDP: A5.15 (Y0), B4.5 (I1), B4.10 (I1)
/DBIN: B4.9 (I0), C-1.P$29 (29), J-1.A15, SYSTEM.22, TMS9995.17
/EXM00: B5.11 (Y4), C-1.P$42 (42)
/EXM40: B5.10 (Y5), C-1.P$43 (43)
/EXM80: B5.9 (Y6), C-1.P$44 (44)
/EXMC0: B5.7 (Y7), C-1.P$45 (45)
/EXP0: A5.12 (Y3), C-1.P$38 (38)
/EXP1: A5.11 (Y4), C-1.P$39 (39)
/EXP2: A5.10 (Y5), C-1.P$40 (40)
/EXP3: A5.9 (Y6), C-1.P$41 (41)
/HOLD: C-1.P$6 (6), R4.1, TMS9995.18
/INT1: C-1.P$4 (4), R6.1, TMS9995.15
/INT4/EC: B4.11 (O), C-1.P$33 (33), TMS9995.14
/IOPORT: A5.4 (G2A), B5.12 (Y3), C-1.P$19 (19)
/KILLSROM: C7.5 (I1), C-1.P$48 (48), R22.1
/MEMEN: B5.4 (G2A), B5.5 (G2B), C-1.P$21 (21), TMS9995.20
/NMI: R5.1, TMS9995.21
/READY: A4.5 (Q), R8.1, TMS9995.23
/RESET: B7.13 (CLR), C7.8 (O), C-1.P$37 (37), R3.2, TMS9995.22
/VDPRD: B4.8 (O), TMS99X8.15
/VDPWR: B4.6 (O), TMS99X8.14
/WE/CPUCLK: B4.4 (I0), C-1.P$31 (31), J-1.A16, SN76489A.5, TMS9995.19
A0: B5.2 (B), C-1.P$34 (34), SYSTEM.1, TMS9995.24
A1: B5.1 (A), C-1.P$32 (32), SYSTEM.27, TMS9995.25
A2: A5.6 (G1), C-1.P$25 (25), J-1.A13, SYSTEM.26, TMS9995.26
A3: A5.5 (G2B), C-1.P$24 (24), J-1.B12, SYSTEM.2, TMS9995.27
A4: A5.3 (C), B3.1 (I0), C-1.P$30 (30), J-1.B15, SYSTEM.23, TMS9995.28
A5: A5.2 (B), B3.2 (I1), C-1.P$28 (28), J-1.B14, SYSTEM.21, TMS9995.29
A6: A5.1 (A), C3.5 (G2B), C-1.P$26 (26), J-1.B13, SYSTEM.24, TMS9995.30
A7: B6.5 (G2B), C4.7 (G), C-1.P$22 (22), J-1.B11, SYSTEM.25, TMS9995.32
A8: B6.3 (C), C-1.P$20 (20), J-1.B10, SYSTEM.3, TMS9995.33
A9: B6.2 (B), C3.3 (C), C-1.P$18 (18), J-1.B9, SYSTEM.4, TMS9995.34
A10: B6.1 (A), C3.2 (B), C-1.P$16 (16), J-1.B8, SYSTEM.5, TMS9995.35
A11: C3.1 (A), C-1.P$14 (14), J-1.B7, SYSTEM.6, TMS9995.36
A12: C4.9 (C), C-1.P$12 (12), J-1.B6, SYSTEM.7, TMS9995.37
A13: C4.10 (B), C-1.P$10 (10), J-1.B5, SYSTEM.8, TMS9995.38
A14: C4.11 (A), C-1.P$23 (23), J-1.A12, SYSTEM.9, TMS99X8.13, TMS9995.39
A15/CRUOUT: C-1.P$8 (8), J-1.B4, SYSTEM.10, TMS9995.40
AD0: IC3.17 (A4), TMS99X8.10
AD1: 4464/1.6, 4464/2.6, IC3.15 (A3), TMS99X8.9
AD2: 4464/1.7, 4464/2.7, IC3.13 (A2), TMS99X8.8
AD3: 4464/1.8, 4464/2.8, IC3.11 (A1), TMS99X8.7
AD4: 4464/1.11, 4464/2.11, IC3.8 (A4), TMS99X8.6
AD5: 4464/1.12, 4464/2.12, IC3.6 (A3), TMS99X8.5
AD6: 4464/1.13, 4464/2.13, IC3.4 (A2), TMS99X8.4
AD7: 4464/1.14, 4464/2.14, IC3.2 (A1), TMS99X8.3
AUDIO: AUDIO.4, C15.2, R23.2, RFAUDIO.1, SN76489A.7
B-Y: JP3.2, TMS99X8.35
CAS: 4464/1.16, 4464/2.16, TMS99X8.2
CLKOUT: A4.3 (CLK), B7.12 (CLK), C-1.P$46 (46), TMS9995.3
CMTIN: C16.1, C-2.4, R14.1, R15.2
CMTOUT: C18.+, C-2.2, R20.2, R21.2
COMVID: C14.1, JP2.1, R11.1, TR2.B
CPUCLK: JP1.1
CRUIN: B3.6 (O), TMS9995.13
D0: C-1.P$17 (17), J-1.A9, SN76489A.3, SYSTEM.19, TMS99X8.24, TMS9995.12
D1: C-1.P$15 (15), J-1.A8, SN76489A.2, SYSTEM.18, TMS99X8.23, TMS9995.11
D2: C-1.P$13 (13), J-1.A7, SN76489A.1, SYSTEM.17, TMS99X8.22, TMS9995.9
D3: C-1.P$11 (11), J-1.A6, SN76489A.15, SYSTEM.16, TMS99X8.21, TMS9995.8
D4: C-1.P$9 (9), J-1.A5, SN76489A.13, SYSTEM.15, TMS99X8.20, TMS9995.7
D5: C-1.P$7 (7), J-1.A4, SN76489A.12, SYSTEM.13, TMS99X8.19, TMS9995.6
D6: C-1.P$5 (5), J-1.A3, SN76489A.11, SYSTEM.12, TMS99X8.18, TMS9995.5
D7: C-1.P$3 (3), J-1.A2, SN76489A.10, SYSTEM.11, TMS99X8.17, TMS9995.4
EXTVDP: JP3.1
G: 4464/1.1, 4464/2.1, IC4.2 (O), IC4.3 (I)
GND: 4464/1.10, 4464/1.18, 4464/2.10, 4464/2.18, A4.7 (GND), A4.11 (CLK), A4.12 (D), A5.8 (GND), AUDIO.1, B3.7 (GND), B4.7 (GND), B5.8 (GND), B6.6 (G1), B6.8 (GND), B7.7 (GND), C1.-, C3.6 (G1), C3.8 (GND), C4.8 (GND), C5.-, C6.7 (GND), C7.7 (GND), C8.-, C9.-, C10.2, C11.2, C12.2, C13.2, C15.1, C53.1, C-1.P$1 (1), C-1.P$2 (2), C-2.3, GND.1, H1.B3,2, H2.B3,2, H3.B3,2, H4.B3,2, H5.B3,2, H6.B3,2, IC3.10 (GND), IC4.7 (GND), J-1.A1, J-1.B1, OSC2.2, PC1.2, PC2.2, PC3.2, PC4.2, PC5.2, PC6.2, PC7.2, PC8.2, PC9.2, PC10.2, PC11.2, PC12.2, PC13.2, PC18.2, POWER.4, R9.1, R11.2, R13.2, R21.1, R100.1, R101.1, R102.1, RFGND.1, SN76489A.8, SYSTEM.14, TMS99X8.12, TMS9995.31, U1.2 (-VIN), U1.4 (-VOUT), VIDEO.1
GROMCLK: J-1.A14, TMS99X8.37
INT: TMS99X8.16
KB/CMT: B3.4 (I0), B4.3 (O)
LAQ/HOLDA: C-1.P$47 (47), TMS9995.16
unnamed: A5.7 (Y7), B6.4 (G2A)
unnamed: A4.10 (PRE), B6.13 (Y2)
unnamed: C6.6 (O), C6.9 (I0)
unnamed: A4.13 (CLR), B6.12 (Y3)
unnamed: B4.1 (I0), C6.5 (I1), C6.8 (O)
unnamed: B6.11 (Y4), C6.4 (I0), C12.1
unnamed: B6.10 (Y5), C6.10 (I1), C13.1
unnamed: C6.2 (I1), C6.11 (O)
unnamed: B3.8 (O), B4.2 (I1), B4.13 (I1), C17.1, R16.2
unnamed: B6.14 (Y1), C6.13 (I1), C11.1
unnamed: B6.15 (Y0), C6.1 (I0), C10.1
unnamed: B3.9 (I0), B3.10 (I1), B3.11 (O)
unnamed: B3.12 (I0), B3.13 (I1), C17.2, R16.1, R17.2, R18.1
unnamed: C6.3 (O), C6.12 (I0), R14.2
unnamed: A4.8 (!Q), B4.12 (I0)
unnamed: C16.2, R15.1, R18.2
unnamed: C7.9 (I0), C7.10 (I1), C7.11 (O)
unnamed: C18.-, R17.1, R19.1
unnamed: B5.14 (Y1), C7.1 (I0)
unnamed: B5.15 (Y0), C7.2 (I1)
unnamed: B7.1 (J), C7.3 (O)
unnamed: B3.5 (I1), C4.5 (Y), R10.2
unnamed: C1.+, R1.1, R2.2
unnamed: C4.4 (D0), J-2.9, RA1.2
unnamed: C4.3 (D1), J-2.10, J-3.3, RA1.3
unnamed: C4.2 (D2), J-2.11, J-3.4, RA1.4
unnamed: C7.12 (I0), C7.13 (I1), R2.1, R3.1
unnamed: C4.1 (D3), J-2.12, J-3.5, RA1.5
unnamed: C4.15 (D4), J-2.13, J-3.6, RA1.6
unnamed: C4.14 (D5), J-2.14, J-3.7, RA1.7
unnamed: C4.13 (D6), J-2.15, RA1.8
unnamed: C4.12 (D7), J-2.16, J-3.8, RA1.9
unnamed: B3.3 (O), C3.4 (G2A)
unnamed: C3.15 (Y0), D1.C
unnamed: C3.14 (Y1), D2.C
unnamed: C3.13 (Y2), D3.C
unnamed: C3.12 (Y3), D4.C
unnamed: C3.9 (Y6), D7.C
unnamed: C3.7 (Y7), D8.C
unnamed: C3.11 (Y4), D5.C, J-3.1
unnamed: C3.10 (Y5), D6.C, J-3.2
unnamed: D1.A, J-2.1
unnamed: D2.A, J-2.2
unnamed: D3.A, J-2.3
unnamed: D4.A, J-2.4
unnamed: D5.A, J-2.5
unnamed: D6.A, J-2.6
unnamed: D7.A, J-2.7
unnamed: D8.A, J-2.8
unnamed: JP1.3, R100.2, R-Y.1
unnamed: B-Y.1, JP3.3, R102.2
unnamed: JP2.3, R101.2, Y.1
unnamed: IC4.6 (O), IC4.9 (I)
unnamed: IC4.10 (O), IC4.13 (I)
unnamed: C14.2, R12.2
unnamed: R12.1, TR2.C
unnamed: C53.2, R23.1
unnamed: OSC2.1, SN76489A.14
OE: IC3.1 (G), IC3.19 (G), IC4.4 (O), IC4.5 (I)
R-Y: JP1.2, TMS99X8.38
R/W: IC4.1 (I), TMS99X8.11
RAS: 4464/1.5, 4464/2.5, TMS99X8.1
RD0: 4464/1.17, IC3.3 (Y4), TMS99X8.32
RD1: 4464/1.15, IC3.5 (Y3), TMS99X8.31
RD2: 4464/1.3, IC3.7 (Y2), TMS99X8.30
RD3: 4464/1.2, IC3.9 (Y1), TMS99X8.29
RD4: 4464/2.17, IC3.12 (Y4), TMS99X8.28
RD5: 4464/2.15, IC3.14 (Y3), TMS99X8.27
RD6: 4464/2.3, IC3.16 (Y2), TMS99X8.26
RD7: 4464/2.2, IC3.18 (Y1), TMS99X8.25
READY: A4.2 (D), C-1.P$27 (27), R7.1, SN76489A.4
RESET: TMS99X8.34
ROMCLK: B7.3 (Q), B7.4 (K), C7.4 (I0), C-1.P$36 (36)
SELEXM: B5.3 (C), C-1.P$35 (35), R9.2
VIDEO: R13.1, RFVIDEO.1, TR2.E, VIDEO.4
W: 4464/1.4, 4464/2.4, JP4.2
XTAL1: OSC1.2, TMS99X8.39, TMS9995.1
XTAL2: OSC1.1, TMS99X8.40, TMS9995.2
Y: JP2.2, TMS99X8.36

Notes on the sheet:
プロセッサ
IPLROM
I/O 割り込み制御
ゲームパッド
キーボード、ゲームパッド
OSC2:大真空DLO555MB_3.579545MHZ
VDP
コネクタ類
PC1-PC17:104

Board: 2 copper layers, 240.0 x 114.3 mm, 117 parts (0 on the bottom side), 153 nets.
